# Keil uVision project DSSU.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DSSU +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\..\common\inc;..\inc;..\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group app
    ../src/: MAIN.C Stimulation.c STM32_Init.c STM32F10X_IT.C System.c DAC2526.c
  group Startup
    ../../common/startup/: stm32f10x_vector.s
  group common files
    ../../common/src/: cortexm3_macro.s stm32f10x_can.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c STM32F10X_TIM.C stm32f10x_usart.c stm32f10x_systick.c
software components: CMSIS:CORE 5.3.0
